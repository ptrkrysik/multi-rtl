<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_sync</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1625000/6.0*4</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/piotr/Odbiornik_gsm/multi_rtl/examples/temp1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/piotr/Odbiornik_gsm/multi_rtl/examples/temp2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1</value></param>
<param><key>num_items</key><value>int(5*samp_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1_0</value></param>
<param><key>num_items</key><value>int(5*samp_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>multi_rtl_source</key>
<param><key>id</key><value>multi_rtl_source_1</value></param>
<param><key>freq0</key><value>939.4e6</value></param>
<param><key>id_string0</key><value>"0"</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>sync_gain0</key><value>25</value></param>
<param><key>freq1</key><value>939.4e6</value></param>
<param><key>id_string1</key><value>"1"</value></param>
<param><key>gain1</key><value>30</value></param>
<param><key>sync_gain1</key><value>25</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync_freq</key><value>939.4e6</value></param>
</block>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multi_rtl_source_1</source_block_id><sink_block_id>blocks_head_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multi_rtl_source_1</source_block_id><sink_block_id>blocks_head_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
