options:
  parameters:
    author: Antoni Przybylik
    description: Sample application for recording to binary files the samples from inputs of two channel multi-rtl receiver
    generate_options: no_gui
    id: mutlirtl_rx_to_cfile_2chan
    output_language: python
    title: mutlirtl_rx_to_cfile_2chan
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fname_ch0
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: fname_ch1
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '10000000000'
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: '10000000000'
    type: complex
  states: {}
- name: multi_rtl_source_0
  id: multi_rtl_source
  parameters:
    corr: '0'
    freq0: '939000000'
    freq1: '939000000'
    gain0: '10'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    id_string0: '0'
    id_string1: '1'
    nchan: '2'
    sample_rate: samp_rate
    sync_freq: '939400000'
    sync_gain0: '10'
    sync_gain1: '10'
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_0, '0', blocks_file_sink_1, '0']
- [multi_rtl_source_0, '0', blocks_head_0, '0']
- [multi_rtl_source_0, '1', blocks_head_0_0, '0']

metadata:
  file_format: 1
